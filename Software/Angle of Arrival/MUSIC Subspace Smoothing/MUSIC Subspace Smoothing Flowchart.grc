<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>delay1</value></param>
<param><key>block_id</key><value>probe82</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>delay2</value></param>
<param><key>block_id</key><value>probe83</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>delay3</value></param>
<param><key>block_id</key><value>probe84</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_points</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>phase_calibration1</value></param>
<param><key>value</key><value>True</value></param>
<param><key>pressed</key><value>False</value></param>
<param><key>released</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>phase_calibration2</value></param>
<param><key>value</key><value>True</value></param>
<param><key>pressed</key><value>False</value></param>
<param><key>released</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>phase_calibration3</value></param>
<param><key>value</key><value>True</value></param>
<param><key>pressed</key><value>False</value></param>
<param><key>released</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.1415926535</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rtl_samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/pi/October Testing/AoA_data.txt</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/pi/October Testing/Phasediff_data.txt</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>file</key><value>/home/pi/October Testing/IQ_data.txt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>2000000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>num_items</key><value>2000000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>num_items</key><value>20000000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_1</value></param>
<param><key>n</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_1</value></param>
<param><key>n</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_2</value></param>
<param><key>n</key><value>50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1 * phase_calibration1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>-1 * phase_calibration2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>-1 * phase_calibration3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>doa_MUSIC_lin_array</key>
<param><key>id</key><value>doa_MUSIC_lin_array_0</value></param>
<param><key>norm_spacing</key><value>0.5</value></param>
<param><key>inputs</key><value>2</value></param>
<param><key>num_targets</key><value>1</value></param>
<param><key>pspectrum_len</key><value>1024</value></param>
</block>
<block>
<key>doa_autocorrelate_smoothing</key>
<param><key>id</key><value>doa_autocorrelate_smoothing_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>4</value></param>
<param><key>overlap_size</key><value>512</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>snapshot_size</key><value>2048</value></param>
<param><key>subarray_size</key><value>2</value></param>
<param><key>subspace_smoothing</key><value>1</value></param>
</block>
<block>
<key>doa_find_local_max</key>
<param><key>id</key><value>doa_find_local_max_0</value></param>
<param><key>num_max_vals</key><value>1</value></param>
<param><key>vector_len</key><value>1024</value></param>
<param><key>x_max</key><value>180.0</value></param>
<param><key>x_min</key><value>0.0</value></param>
</block>
<block>
<key>doa_qt_compass</key>
<param><key>id</key><value>doa_qt_compass_0</value></param>
<param><key>arc_bias</key><value>0</value></param>
<param><key>max_val</key><value>360</value></param>
<param><key>min_val</key><value>0</value></param>
<param><key>name</key><value>"Angle of Arrival"</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>step</key><value>10</value></param>
<param><key>update_time</key><value>0.10</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe82</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe83</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe84</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>180</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Phase Difference vs. Time 1</value></param>
<param><key>size</key><value>int(rtl_samp_rate/float(n_points)/3)</value></param>
<param><key>srate</key><value>rtl_samp_rate/float(n_points)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Phase Difference"</value></param>
<param><key>yunit</key><value>"Time"</value></param>
<param><key>ymax</key><value>pi</value></param>
<param><key>ymin</key><value>-pi</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Phase Difference vs. Time 2</value></param>
<param><key>size</key><value>int(rtl_samp_rate/float(n_points)/3)</value></param>
<param><key>srate</key><value>rtl_samp_rate/float(n_points)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Phase Difference"</value></param>
<param><key>yunit</key><value>"Time"</value></param>
<param><key>ymax</key><value>pi</value></param>
<param><key>ymin</key><value>-pi</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Phase Difference vs. Time 3</value></param>
<param><key>size</key><value>int(rtl_samp_rate/float(n_points)/3)</value></param>
<param><key>srate</key><value>rtl_samp_rate/float(n_points)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>"Phase Difference"</value></param>
<param><key>yunit</key><value>"Time"</value></param>
<param><key>ymax</key><value>pi</value></param>
<param><key>ymin</key><value>-pi</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>1024</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>0.175781</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>2500</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>rtl=1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>2500</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>rtl=2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>2500</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>rtl=4</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>2500</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>rtl=3</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>data1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>data2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>rtl4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_2</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_2_0</value></param>
<param><key>stream_id</key><value>rtl2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_2_0_0</value></param>
<param><key>stream_id</key><value>rtl3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>data3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>data4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>data4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1</value></param>
<param><key>stream_id</key><value>data3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0</value></param>
<param><key>stream_id</key><value>data2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_2</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>data1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>rtl2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>rtl3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>rtl4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0</value></param>
<param><key>stream_id</key><value>rtl3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_1</value></param>
<param><key>stream_id</key><value>rtl2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_1_0</value></param>
<param><key>stream_id</key><value>rtl4</value></param>
</block>
<block>
<key>xcorr_capon_ccf</key>
<param><key>id</key><value>xcorr_capon_ccf_0</value></param>
<param><key>vlen</key><value>100</value></param>
</block>
<block>
<key>xcorr_capon_ccf</key>
<param><key>id</key><value>xcorr_capon_ccf_0_0</value></param>
<param><key>vlen</key><value>100</value></param>
</block>
<block>
<key>xcorr_capon_ccf</key>
<param><key>id</key><value>xcorr_capon_ccf_0_1</value></param>
<param><key>vlen</key><value>100</value></param>
</block>
<block>
<key>xcorr_delay</key>
<param><key>id</key><value>xcorr_delay_0_0_0_0</value></param>
<param><key>delay</key><value>delay1</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>xcorr_delay</key>
<param><key>id</key><value>xcorr_delay_0_0_0_0_0</value></param>
<param><key>delay</key><value>delay2</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>xcorr_delay</key>
<param><key>id</key><value>xcorr_delay_0_0_0_0_1</value></param>
<param><key>delay</key><value>delay3</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>xcorr_hold_ff</key>
<param><key>id</key><value>xcorr_hold_ff_0</value></param>
<param><key>hold</key><value>phase_calibration1</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>xcorr_hold_ff</key>
<param><key>id</key><value>xcorr_hold_ff_0_0</value></param>
<param><key>hold</key><value>phase_calibration2</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>xcorr_hold_ff</key>
<param><key>id</key><value>xcorr_hold_ff_0_1</value></param>
<param><key>hold</key><value>phase_calibration3</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>xcorr_message_sink_f</key>
<param><key>id</key><value>xcorr_message_sink_f_0</value></param>
</block>
<block>
<key>xcorr_message_sink_f</key>
<param><key>id</key><value>xcorr_message_sink_f_0_0</value></param>
</block>
<block>
<key>xcorr_message_sink_f</key>
<param><key>id</key><value>xcorr_message_sink_f_0_1</value></param>
</block>
<block>
<key>xcorr_multiply_exp_cc</key>
<param><key>id</key><value>xcorr_multiply_exp_cc_0</value></param>
<param><key>arg</key><value>0</value></param>
</block>
<block>
<key>xcorr_multiply_exp_cc</key>
<param><key>id</key><value>xcorr_multiply_exp_cc_0_0</value></param>
<param><key>arg</key><value>0</value></param>
</block>
<block>
<key>xcorr_multiply_exp_cc</key>
<param><key>id</key><value>xcorr_multiply_exp_cc_0_1</value></param>
<param><key>arg</key><value>0</value></param>
</block>
<block>
<key>xcorr_sample_offset_cci</key>
<param><key>id</key><value>xcorr_sample_offset_cci_0</value></param>
<param><key>num_xcorr</key><value>2</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>vector_len</key><value>131072</value></param>
</block>
<block>
<key>xcorr_sample_offset_cci</key>
<param><key>id</key><value>xcorr_sample_offset_cci_0_0</value></param>
<param><key>num_xcorr</key><value>2</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>vector_len</key><value>131072</value></param>
</block>
<block>
<key>xcorr_sample_offset_cci</key>
<param><key>id</key><value>xcorr_sample_offset_cci_0_0_0</value></param>
<param><key>num_xcorr</key><value>2</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>vector_len</key><value>131072</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>xcorr_multiply_exp_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>xcorr_multiply_exp_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_1</source_block_id><sink_block_id>xcorr_multiply_exp_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_2</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>xcorr_message_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>xcorr_message_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>xcorr_message_sink_f_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>xcorr_sample_offset_cci_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>xcorr_sample_offset_cci_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>xcorr_sample_offset_cci_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_0</source_block_id><sink_block_id>xcorr_sample_offset_cci_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_0_0</source_block_id><sink_block_id>xcorr_capon_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_1</source_block_id><sink_block_id>xcorr_capon_ccf_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0_2</source_block_id><sink_block_id>xcorr_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>xcorr_sample_offset_cci_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1_0</source_block_id><sink_block_id>xcorr_sample_offset_cci_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2</source_block_id><sink_block_id>xcorr_capon_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2_0</source_block_id><sink_block_id>xcorr_capon_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2_1</source_block_id><sink_block_id>xcorr_capon_ccf_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>doa_find_local_max_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_smoothing_0</source_block_id><sink_block_id>doa_MUSIC_lin_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>doa_qt_compass_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>virtual_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>virtual_sink_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_1</source_block_id><sink_block_id>virtual_sink_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>doa_autocorrelate_smoothing_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1</source_block_id><sink_block_id>doa_autocorrelate_smoothing_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0</source_block_id><sink_block_id>doa_autocorrelate_smoothing_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_2</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>doa_autocorrelate_smoothing_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0</source_block_id><sink_block_id>xcorr_delay_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_1</source_block_id><sink_block_id>xcorr_delay_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_1_0</source_block_id><sink_block_id>xcorr_delay_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0</source_block_id><sink_block_id>xcorr_hold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0_0</source_block_id><sink_block_id>xcorr_hold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_capon_ccf_0_1</source_block_id><sink_block_id>xcorr_hold_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_delay_0_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_delay_0_0_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_delay_0_0_0_0_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_hold_ff_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_hold_ff_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_hold_ff_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_message_sink_f_0</source_block_id><sink_block_id>xcorr_multiply_exp_cc_0</sink_block_id><source_key>out</source_key><sink_key>arg</sink_key></connection>
<connection><source_block_id>xcorr_message_sink_f_0_0</source_block_id><sink_block_id>xcorr_multiply_exp_cc_0_0</sink_block_id><source_key>out</source_key><sink_key>arg</sink_key></connection>
<connection><source_block_id>xcorr_message_sink_f_0_1</source_block_id><sink_block_id>xcorr_multiply_exp_cc_0_1</sink_block_id><source_key>out</source_key><sink_key>arg</sink_key></connection>
<connection><source_block_id>xcorr_multiply_exp_cc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_multiply_exp_cc_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_multiply_exp_cc_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_multiply_exp_cc_0_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_multiply_exp_cc_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_multiply_exp_cc_0_1</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_sample_offset_cci_0</source_block_id><sink_block_id>probe82</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_sample_offset_cci_0_0</source_block_id><sink_block_id>probe83</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcorr_sample_offset_cci_0_0_0</source_block_id><sink_block_id>probe84</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
