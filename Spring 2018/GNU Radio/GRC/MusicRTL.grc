<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>run_MUSIC_calib_lin_array_simulation</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amv0</value></param>
<param><key>value</key><value>numpy.multiply(ant_coeffs, amv0_true)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amv0_true</value></param>
<param><key>value</key><value>numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amv1</value></param>
<param><key>value</key><value>numpy.multiply(ant_coeffs, amv1_true)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amv1_true</value></param>
<param><key>value</key><value>numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ant_coeffs</value></param>
<param><key>comment</key><value>These simulated antenna coefficients need 
to be the same as those used in 
apps/run_calib_lin_array_simulation.grc</value></param>
<param><key>value</key><value>input_variables.AntGains*numpy.exp(1j*input_variables.AntPhases)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ant_locs</value></param>
<param><key>value</key><value>numpy.dot(0.5, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_calibration_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>array_manifold_matrix</value></param>
<param><key>value</key><value>numpy.array([amv0, amv1]).transpose()</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value9</key><value>numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])</value></param>
<param><key>value10</key><value>numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])</value></param>
<param><key>value12</key><value>"calibration_lin_array_simulated.cfg"</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value11</key><value>"/tmp"</value></param>
<param><key>field0</key><value>SampleRate</value></param>
<param><key>field1</key><value>ToneFreq1</value></param>
<param><key>field10</key><value>AntPhases</value></param>
<param><key>field11</key><value>DirectoryConfigFiles</value></param>
<param><key>field12</key><value>AntennaCalibration</value></param>
<param><key>field2</key><value>ToneFreq2</value></param>
<param><key>field3</key><value>NormSpacing</value></param>
<param><key>field4</key><value>NumTargets</value></param>
<param><key>field5</key><value>NumArrayElements</value></param>
<param><key>field6</key><value>PSpectrumLength</value></param>
<param><key>field7</key><value>SnapshotSize</value></param>
<param><key>field8</key><value>OverlapSize</value></param>
<param><key>field9</key><value>AntGains</value></param>
<param><key>value3</key><value>0.5</value></param>
<param><key>value5</key><value>4</value></param>
<param><key>value4</key><value>2</value></param>
<param><key>value8</key><value>2**9</value></param>
<param><key>value6</key><value>2**10</value></param>
<param><key>value0</key><value>320000</value></param>
<param><key>value7</key><value>2**11</value></param>
<param><key>value1</key><value>10000</value></param>
<param><key>value2</key><value>20000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta0</value></param>
<param><key>value</key><value>numpy.pi*theta0_deg/180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>theta0_deg</value></param>
<param><key>value</key><value>30</value></param>
<param><key>label</key><value>AoA</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta1</value></param>
<param><key>value</key><value>numpy.pi*theta1_deg/180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>theta1_deg</value></param>
<param><key>value</key><value>123</value></param>
<param><key>label</key><value>AoA</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>input_variables.SampleRate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>doa_MUSIC_lin_array</key>
<param><key>id</key><value>doa_MUSIC_lin_array_0</value></param>
<param><key>norm_spacing</key><value>0.1728</value></param>
<param><key>inputs</key><value>2</value></param>
<param><key>num_targets</key><value>1</value></param>
<param><key>pspectrum_len</key><value>input_variables.PSpectrumLength</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>2</value></param>
<param><key>overlap_size</key><value>1024</value></param>
<param><key>snapshot_size</key><value>input_variables.SnapshotSize</value></param>
</block>
<block>
<key>doa_qt_compass</key>
<param><key>id</key><value>doa_compass_0</value></param>
<param><key>arc_bias</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>max_val</key><value>360</value></param>
<param><key>min_val</key><value>0</value></param>
<param><key>name</key><value>""</value></param>
<param><key>step</key><value>10</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>doa_find_local_max</key>
<param><key>id</key><value>doa_find_local_max_0</value></param>
<param><key>num_max_vals</key><value>1</value></param>
<param><key>vector_len</key><value>input_variables.PSpectrumLength</value></param>
<param><key>x_max</key><value>360.0</value></param>
<param><key>x_min</key><value>0.0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>98000</value></param>
<param><key>freq0</key><value>433.9e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>rtl=0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>98000</value></param>
<param><key>freq0</key><value>433.9e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>rtl=1</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Pseudo-Spectrum</value></param>
<param><key>label1</key><value>Direction of Arrival</value></param>
<param><key>label2</key><value>Direction of Arrival</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>doa_find_local_max_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>doa_MUSIC_lin_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>doa_compass_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
