<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value12</key><value>"calibration_lin_array_simulated.cfg"</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value11</key><value>"/tmp"</value></param>
<param><key>field0</key><value>ToneFreq</value></param>
<param><key>field1</key><value>SampleRate</value></param>
<param><key>field10</key><value>PSpectrumLength</value></param>
<param><key>field11</key><value>DirectoryConfigFiles</value></param>
<param><key>field12</key><value>AntennaCalibration</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>RxAddr</value></param>
<param><key>field4</key><value>Gain</value></param>
<param><key>field5</key><value>NumArrayElements</value></param>
<param><key>field6</key><value>NormSpacing</value></param>
<param><key>field7</key><value>SnapshotSize</value></param>
<param><key>field8</key><value>OverlapSize</value></param>
<param><key>field9</key><value>NumTargets</value></param>
<param><key>value4</key><value>60</value></param>
<param><key>value6</key><value>500</value></param>
<param><key>value5</key><value>2</value></param>
<param><key>value9</key><value>1</value></param>
<param><key>value8</key><value>512</value></param>
<param><key>value10</key><value>1024</value></param>
<param><key>value3</key><value>192168102</value></param>
<param><key>value1</key><value>1000000</value></param>
<param><key>value7</key><value>2048</value></param>
<param><key>value0</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0_0</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>samples_per_second</key><value>320000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>doa_MUSIC_lin_array</key>
<param><key>id</key><value>doa_MUSIC_lin_array_0</value></param>
<param><key>norm_spacing</key><value>0.1728</value></param>
<param><key>inputs</key><value>2</value></param>
<param><key>num_targets</key><value>1</value></param>
<param><key>pspectrum_len</key><value>1024</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>2</value></param>
<param><key>overlap_size</key><value>1024</value></param>
<param><key>snapshot_size</key><value>2048</value></param>
</block>
<block>
<key>doa_find_local_max</key>
<param><key>id</key><value>doa_find_local_max_0</value></param>
<param><key>num_max_vals</key><value>1</value></param>
<param><key>vector_len</key><value>1024</value></param>
<param><key>x_max</key><value>180.0</value></param>
<param><key>x_min</key><value>0.0</value></param>
</block>
<block>
<key>doa_qt_compass</key>
<param><key>id</key><value>doa_qt_compass_0</value></param>
<param><key>arc_bias</key><value>0</value></param>
<param><key>max_val</key><value>180</value></param>
<param><key>min_val</key><value>0</value></param>
<param><key>name</key><value>""</value></param>
<param><key>step</key><value>10</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>98000</value></param>
<param><key>freq0</key><value>433.9e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>rtl=1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>98000</value></param>
<param><key>freq0</key><value>433.9e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>rtl=2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>doa_find_local_max_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>doa_MUSIC_lin_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>doa_qt_compass_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_1</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
